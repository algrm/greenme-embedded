# Keil uVision project Cube.uvproj, settings and files
target Cube (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Cube +hex
  c flags: Optim=2 wLevel=2
  c define: ARM_MATH_CM0 USE_STDPERIPH_DRIVER STM32F0XX HSE_VALUE=16000000
  c include: Inc;Libraries\CMSIS\Include;Libraries\CMSIS\ST\STM32F0xx\Include;Libraries\STM32F0xx_StdPeriph_Driver\inc;.\Libraries\Quasinil\Inc;.\Libraries\FFT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./Src/: ARMN8LW.c Averages.c CCS811.c CCS811_firmware.c Cfg.c ColorSensor.c crc.c dBAMeter.c Debug.c Display.c doDisplay.c Eep25AA.c Filters.c Flicker.c Font.c HDC1080.c I2CStdSensors.c I2CExtSensors.c Images.c Init.c ISL29035.c main.c Messaging.c MMA8453.c Radio.c startup_stm32f0xx.s utils.c
    ./Inc/: definitions.h
  group STM32F0xx_StdPeriph_Driver
    ./Src/: system_stm32f0xx.c stm32f0xx_it.c
    Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_gpio.c stm32f0xx_syscfg.c stm32f0xx_exti.c
    ./Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_iwdg.c stm32f0xx_dbgmcu.c stm32f0xx_usart.c stm32f0xx_flash.c stm32f0xx_tim.c stm32f0xx_dma.c stm32f0xx_crc.c stm32f0xx_adc.c stm32f0xx_spi.c stm32f0xx_i2c.c
  group QuasinilDrv
    ./Libraries/Quasinil/Src/: GPIODef.c Tim.c Time.c Uart2.c Watchdog.c I2C1.c I2C2.c I2C.c Uarts.c
  group FFT
    ./Libraries/FFT/: arm_cfft_radix4_f32.c arm_cmplx_mag_f32.c arm_rfft_f32.c arm_rfft_init_f32.c arm_bitreversal.c arm_cfft_radix4_init_f32.c
  group ReadMe
    ./: ReadMe.txt ReleaseNotes.txt
